Commit message: update project

File: assets/robot/arm_without_gazabo.urdf (robot description, URDF)
Before this commit: robot movo, 17 links, 16 joints
Links:
- link right_wrist_3_link: geometry visual mesh filename=movo_description/meshes/manipulation/jaco/visual/kinova_act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
